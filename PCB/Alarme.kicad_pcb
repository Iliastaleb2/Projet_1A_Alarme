# Repository Iliastaleb2/Projet_1A_Alarme

File README.md:

# Projet-1A : Alarme-détection-laser-sécurisée-par-des-codes-de-protection (sorties)
Projet de 1ère année à l'ENSEA. Avec mon binôme nous nous sommes focalisés sur les sorties (c'est à dire l'alarme et l'émission des signaux sonores).

## KiCad design PCB/Alarme.kicad_pcb

File PCB/README.md:

# Description

Plus précisément, lorsque le faisceau LASER est interrompu, une alarme à  bi-tons ou à sinusoïdalement progressive (ajustable via un cavalier) est déclenchée.
Pour arrêter l’alarme, différents codes doivent être saisis, avec un « supercode » permettant malgré tout de stopper l’alarme en cas d’erreur de saisie des codes.

Avec mon partenaire, notre rôle était de gérer la sortie, c’est-à-dire le signal sonore et la variation de fréquence à partir d’un signal carré transmis par le microcontrôleur STM32L476RG entre 0 et 3,3 V.

Pour cela, nous avons principalement utilisé :

- Un VCO (XR2206 pour générer le signal et basculer entre bi-ton et progressif)

- Des transistors (NPN 2N1711 et PNP 2N2905 pour amplifier le signal)

- Un convertisseur IA1215S DC-DC (12 V vers 15 V pour alimenter le circuit audio)

- Un AOP TL082 (pour intégrer et inverser le signal)

- Un haut-parleur KSSG1708

## Schématique : 

## Bottom :

## Top :

Parts:
C2: 22n; CP_Radial_Tantal_D4.5mm_P5.00mm
C3: 47u; CP_Radial_Tantal_D4.5mm_P5.00mm
C4, C5, C8, C9, C10, C12, C13, C14, C17, C19, C20: 10n; CP_Radial_Tantal_D4.5mm_P5.00mm
C7: 1u; CP_Radial_Tantal_D4.5mm_P5.00mm
C15: 10u; CP_Radial_Tantal_D4.5mm_P5.00mm
H5, H6, H7, H8: MountingHole_Pad; MountingHole_3.2mm_M3_DIN965_Pad
J1: Conn_01x02; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J2: Conn_01x03; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
JP2, JP4, JP5: Jumper_3_Open; PinHeader_1x03_P2.54mm_Vertical
LS1: KSSG1708; SPKR_KSSG1708; PARTREV 1.1
PS1: IA1215S; Converter_DCDC_XP_POWER-IAxxxxS_THT
Q1, Q3: 2N1711_PBFREE; TO39; Mouser Part Number 610-2N1711
Q2, Q4: 2N2905_PBFREE; TO39; Mouser Part Number 610-2N2905
R1: 100k; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
R2: 470k; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
R4, R6, R7: 15k; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
R5, R9, R11: 3.3k; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
R8: 3k; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
R10: 10k; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
R12, R13: 5.1k; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
R14: 400; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
R15: 200; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
RV2: 20k; Potentiometer_ACP_CA9-H5_Horizontal
RV3: 50k; Potentiometer_ACP_CA9-H5_Horizontal
RV4: 500; Potentiometer_ACP_CA9-H5_Horizontal
U1: TL082; DIP794W53P254L959H508Q8N
U2: XR2206_11_12EB; DIP-16_W7.62mm_LongPads; PART_REV 1.03; DIGI-KEY_PART_NUMBER 1016-1428-ND

Connections:
+15V: C5.1, C9.1, C12.1, C14.1, C20.2, PS1.6 (+Vout), Q4.1 (E), R7.2, R10.1, R13.2, U1.8 (V+)
+BATT(12V): C10.2, J1.1, PS1.1 (+Vin)
-15V: C4.2, C13.1, C19.2, PS1.4 (-Vout), R6.1, U1.4 (V-)
BIAS: C8.2, U2.10 (BIAS)
FSKI: JP5.1 (A), U2.9 (FSKI)
GND: C4.1, C5.2, C8.1, C9.2, C12.2, C13.2, C14.2, C15.2, C17.2, C19.1, C20.1, H5.1, H6.1, H7.1, H8.1, J2.3, LS1.N, PS1.5 (0V), Q3.1 (E), R12.1, R14.2, R15.2, RV2.2, U1.3 (+), U1.5 (+), U2.1 (AMSI), U2.12 (GND)
GNDPWR: C10.1, J1.2, PS1.2 (-Vin)
MO: RV3.1, U2.3 (MO)
unnamed: C2.2, R2.2, R5.1, U1.1
unnamed: C3.2, R4.1
unnamed: C15.1, R12.2, R13.1, RV3.2, RV3.3
unnamed: JP2.3 (B), R15.1
unnamed: JP4.3 (B), R14.1
unnamed: Q1.2 (B), Q2.2 (B), R4.2
unnamed: Q1.3 (C), R7.1
unnamed: LS1.P, Q1.1 (E), Q2.1 (E)
unnamed: Q2.3 (C), R6.2
unnamed: Q3.2 (B), R9.2
unnamed: Q3.3 (C), R10.2, R11.2
unnamed: Q4.2 (B), R11.1
unnamed: C2.1, R1.2, R2.1, U1.2 (-)
unnamed: R5.2, R8.1, U1.6 (-)
OUT_SIN_BI: C3.1, U2.2 (STO)
SINT: JP4.1 (A), R8.2, U1.7
SUPPLY: C17.1, Q4.3 (C), U2.4 (VCC)
SYM1: RV2.1, U2.15 (SYMA1)
SYM2: RV2.3, U2.16 (SYMA2)
Sig_Square: JP5.3 (B), R1.1
Sig_alarm: J2.2, JP5.2 (C)
TC1: C7.1, U2.5 (TC1)
TC2: C7.2, U2.6 (TC2)
TR1: JP4.2 (C), U2.7 (TR1)
TR2: JP2.2 (C), U2.8 (TR2)
Valid_alarm: J2.1, R9.1
WAVE1: RV4.2, RV4.3, U2.13 (WAVEA1)
WAVE2: RV4.1, U2.14 (WAVEA2)

Notes on the sheet:
BI-TON
R8/R5=3/3.33
F1=1/R1C =2500Hz F2=1/R2C =5000Hz
SINUSOIDAL
3 - VCO XR2206
1 - intégrateur : TL082
0 - Connecteurs
Trous de fixations
4 - Haut-Parleur K5SG1708
2 - Module d'amplification
12 V à 15 V

Board: 2 copper layers, 72.0 x 72.0 mm, 49 parts (0 on the bottom side), 36 nets.

## Commit log

2025-09-06 Projet kicad
2025-09-06 ajout projet kicad
